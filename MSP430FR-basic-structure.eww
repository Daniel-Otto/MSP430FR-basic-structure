<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MSP430FR-basic-structure.ewp</path>
    </project>
    <batchBuild />
</workspace>
